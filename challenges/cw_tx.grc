options:
  parameters:
    author: corey
    copyright: RFHS
    description: Transmit Morse Code for CW Challenge
    generate_options: no_gui
    id: cw_tx
    output_language: python
    run_options: run
    title: CW Transmit
  states: {}

blocks:
- name: cw_samp_rate
  id: variable
  parameters:
    value: int(samp_rate/100)
  states: {}
- name: antenna
  id: parameter
  parameters:
    label: Antenna
    short_id: a
    type: str
    value: ''
  states: {}
- name: bbgain
  id: parameter
  parameters:
    label: Base Band Gain
    short_id: b
    type: eng_float
    value: '20'
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: int(1.2/speed*cw_samp_rate/2)
    max_iter: '4000'
    scale: 1/(1.2/speed*cw_samp_rate/2)
    type: float
  states: {}
- name: deviceargs
  id: parameter
  parameters:
    label: Device String
    short_id: d
    type: str
    value: file=/dev/null,freq=100e6,label='Complex Sampled (IQ) File',rate=1e6,throttle=false
  states: {}
- name: flag
  id: parameter
  parameters:
    label: Flag
    short_id: m
    type: str
    value: RFHS
  states: {}
- name: freq
  id: parameter
  parameters:
    label: Center Frequency
    short_id: f
    type: intx
    value: '146550000'
  states: {}
- name: ifgain
  id: parameter
  parameters:
    label: IF Gain
    short_id: i
    type: eng_float
    value: '20'
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    ant0: antenna
    args: deviceargs
    bb_gain0: bbgain
    freq0: freq
    gain0: rfgain
    if_gain0: ifgain
    sample_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: cw_samp_rate
    interp: samp_rate
    type: fcc
  states: {}
- name: rfgain
  id: parameter
  parameters:
    label: RF Gain
    short_id: g
    type: eng_float
    value: '32'
  states: {}
- name: rfhs_cw_source_0
  id: rfhs_cw_source
  parameters:
    samp_rate: cw_samp_rate
    text: flag
    wpm: '15'
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Sample Rate
    short_id: s
    type: intx
    value: '2400000'
  states: {}
- name: speed
  id: parameter
  parameters:
    label: Speed WPM
    short_id: w
    type: intx
    value: '15'
  states: {}

connections:
- [blocks_moving_average_xx_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', osmosdr_sink_0, '0']
- [rfhs_cw_source_0, '0', blocks_moving_average_xx_0, '0']

metadata:
  file_format: 1
