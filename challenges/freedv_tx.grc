options:
  parameters:
    author: Corey Koval
    category: Custom
    description: FreeDV Transmitter capable of USB and LSB
    generate_options: no_gui
    id: freedv_tx
    output_language: python
    run_options: run
    title: FreeDV Transmitter
  states: {}

blocks:
- name: carrier_level
  id: variable
  parameters:
    value: '1'
  states: {}
- name: filter_width
  id: variable
  parameters:
    value: 2.7e3
  states: {}
- name: high
  id: variable
  parameters:
    value: low+filter_width
  states: {}
- name: if_samp_rate
  id: variable
  parameters:
    value: '8000'
  states: {}
- name: low
  id: variable
  parameters:
    value: '300'
  states: {}
- name: voice_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: '3000'
    gain: '1.0'
    samp_rate: wav_samp_rate
    width: '500'
    win: window.WIN_HAMMING
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: carrier_level
    freq: '0'
    offset: '0'
    phase: '0'
    samp_rate: if_samp_rate
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {state: disabled}
- name: audio_gain
  id: parameter
  parameters:
    hide: part
    label: Audio Gain
    type: eng_float
    value: '0.6'
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    gain: '1'
    high_cutoff_freq: '-low if mode == ''lsb'' else high'
    interp: '1'
    low_cutoff_freq: '-high if mode == ''lsb'' else low'
    samp_rate: if_samp_rate
    type: interp_fir_filter_ccc
    width: '300'
    win: window.WIN_HAMMING
  states: {}
- name: bb_gain
  id: parameter
  parameters:
    label: Base Band Gain
    short_id: b
    type: eng_float
    value: '20'
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_short_0
  id: blocks_float_to_short
  parameters:
    scale: 2**16/2
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: audio_gain
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_short_to_float_0_0
  id: blocks_short_to_float
  parameters:
    scale: 2**15
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: rf_samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: wav_file
    repeat: 'False'
  states: {}
- name: dev
  id: parameter
  parameters:
    label: device
    short_id: d
    type: str
    value: '''hackrf=0'''
  states: {}
- name: freq
  id: parameter
  parameters:
    label: Center Frequency
    short_id: f
    type: eng_float
    value: 445e6
  states: {}
- name: if_gain
  id: parameter
  parameters:
    label: IF Gain
    short_id: i
    type: eng_float
    value: '20'
  states: {}
- name: mode
  id: parameter
  parameters:
    label: Mode (usb or lsb)
    short_id: m
    type: str
    value: usb
  states: {}
- name: note_0
  id: note
  parameters:
    note: Hack RF uses the RF Gain to enable or disable (<14) the RF amplifier. HackRF uses IF Gain for fine gain adjustment. BladeRF Only uses RF gain, and is generally best set around 40 to 45.
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: dev
    bb_gain0: bb_gain
    corr0: ppm
    freq0: freq
    gain0: rf_gain
    if_gain0: if_gain
    sample_rate: rf_samp_rate
    sync: none
    type: fc32
  states: {}
- name: ppm
  id: parameter
  parameters:
    hide: part
    label: PPM
    short_id: p
    type: intx
    value: '0'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: int(wav_samp_rate)
    interp: int(if_samp_rate)
    taps: voice_taps
    type: fff
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: int(if_samp_rate)
    interp: int(rf_samp_rate)
    taps: ''
    type: ccc
  states: {}
- name: rf_gain
  id: parameter
  parameters:
    label: RF Gain
    short_id: g
    type: eng_float
    value: '20'
  states: {}
- name: rf_samp_rate
  id: parameter
  parameters:
    label: RF Sample Rate
    short_id: r
    type: intx
    value: '2000000'
  states: {}
- name: text
  id: parameter
  parameters:
    label: Message Text
    short_id: t
    type: str
    value: '"RFHS"'
  states: {}
- name: vocoder_freedv_tx_ss_0
  id: vocoder_freedv_tx_ss
  parameters:
    clip_val: 'False'
    interleave_frames: '1'
    mode: freedv_api.MODE_1600
    tx_bpf_val: 'True'
    txt_msg: text
  states: {}
- name: wav_file
  id: parameter
  parameters:
    label: Wav File
    short_id: w
    type: str
    value: examples/example_voice.wav
  states: {}
- name: wav_samp_rate
  id: parameter
  parameters:
    label: Wav Sample Rate
    short_id: a
    type: intx
    value: '48000'
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_float_to_complex_0, '1']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [band_pass_filter_0, '0', rational_resampler_xxx_0_0, '0']
- [blocks_float_to_complex_0, '0', band_pass_filter_0, '0']
- [blocks_float_to_complex_0, '0', blocks_multiply_xx_0, '0']
- [blocks_float_to_short_0, '0', vocoder_freedv_tx_ss_0, '0']
- [blocks_multiply_const_vxx_0, '0', rational_resampler_xxx_0, '0']
- [blocks_multiply_xx_0, '0', band_pass_filter_0, '0']
- [blocks_short_to_float_0_0, '0', blocks_float_to_complex_0, '0']
- [blocks_throttle_0, '0', blocks_null_sink_0, '0']
- [blocks_wavfile_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [rational_resampler_xxx_0, '0', blocks_float_to_short_0, '0']
- [rational_resampler_xxx_0_0, '0', blocks_throttle_0, '0']
- [rational_resampler_xxx_0_0, '0', osmosdr_sink_0, '0']
- [vocoder_freedv_tx_ss_0, '0', blocks_short_to_float_0_0, '0']

metadata:
  file_format: 1
