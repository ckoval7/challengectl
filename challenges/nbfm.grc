options:
  parameters:
    author: Corey Koval
    description: NBFM Transmitter with adjustable audio levels
    generate_options: no_gui
    id: nbfm
    output_language: python
    run_options: run
    title: NBFM Transmitter
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: if_rate
  id: variable
  parameters:
    value: audio_rate*4
  states: {}
- name: variable_low_pass_filter_taps_0
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: '3000'
    gain: audio_gain
    samp_rate: wav_rate
    width: '300'
    win: window.WIN_HAMMING
  states: {}
- name: analog_nbfm_tx_0
  id: analog_nbfm_tx
  parameters:
    audio_rate: audio_rate
    fh: '-1.0'
    max_dev: 5e3
    quad_rate: if_rate
    tau: '75e-6'
  states: {}
- name: audio_gain
  id: parameter
  parameters:
    hide: part
    label: Audio Gain
    type: eng_float
    value: '0.6'
  states: {}
- name: bb_gain
  id: parameter
  parameters:
    label: Base Band Gain
    short_id: b
    type: eng_float
    value: '20'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: rf_samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: wav_file
    repeat: 'False'
  states: {}
- name: dev
  id: parameter
  parameters:
    label: Device String
    short_id: d
    type: str
    value: '''bladerf=0'''
  states: {}
- name: freq
  id: parameter
  parameters:
    label: Center Frequency
    short_id: f
    type: intx
    value: int(449e6)
  states: {}
- name: if_gain
  id: parameter
  parameters:
    label: IF Gain
    short_id: i
    type: eng_float
    value: '20'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 3e3
    decim: '1'
    gain: '1'
    samp_rate: rf_samp_rate
    type: fir_filter_ccf
    width: 2e3
    win: window.WIN_HAMMING
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    ant0: antenna
    args: dev
    bb_gain0: bb_gain
    corr0: ppm
    freq0: freq
    gain0: rf_gain
    if_gain0: if_gain
    sample_rate: rf_samp_rate
    sync: none
    type: fc32
  states: {}
- name: ppm
  id: parameter
  parameters:
    hide: part
    label: PPM
    short_id: p
    type: intx
    value: '0'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: if_rate
    interp: rf_samp_rate
    type: ccc
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: wav_rate
    interp: audio_rate
    taps: variable_low_pass_filter_taps_0
    type: fff
  states: {}
- name: rf_gain
  id: parameter
  parameters:
    label: RF Gain
    short_id: g
    type: eng_float
    value: '20'
  states: {}
- name: rf_samp_rate
  id: parameter
  parameters:
    label: RF Sample Rate
    short_id: r
    type: intx
    value: '2000000'
  states: {}
- name: wav_file
  id: parameter
  parameters:
    label: Wav File
    short_id: w
    type: str
    value: ./test.wav
  states: {}
- name: wav_rate
  id: parameter
  parameters:
    label: Wav File Audio Sample Rate
    short_id: a
    type: intx
    value: '48000'
  states: {}
- name: antenna
  id: parameter
  parameters:
    label: Antenna
    type: str
    value: ''
  states: {}

connections:
- [analog_nbfm_tx_0, '0', rational_resampler_xxx_0, '0']
- [blocks_throttle_0, '0', blocks_null_sink_0, '0']
- [blocks_wavfile_source_0, '0', rational_resampler_xxx_1, '0']
- [low_pass_filter_0, '0', blocks_throttle_0, '0']
- [low_pass_filter_0, '0', osmosdr_sink_0, '0']
- [rational_resampler_xxx_0, '0', low_pass_filter_0, '0']
- [rational_resampler_xxx_1, '0', analog_nbfm_tx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
