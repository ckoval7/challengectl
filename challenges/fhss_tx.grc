options:
  parameters:
    author: Corey Koval
    generate_options: no_gui
    id: fhss_tx
    output_language: python
    run_options: run
    title: Freq Hopper
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: hopset
  id: variable
  parameters:
    value: hop_set.mkhopset(seed,rand_low,rand_high,hop_rate,hop_time)
  states: {}
- name: if_rate
  id: variable
  parameters:
    value: audio_rate*4
  states: {}
- name: num_channels
  id: variable
  parameters:
    value: ((((rf_rate/2)-channel_spacing)/channel_spacing)*2)+1
  states: {}
- name: rand_high
  id: variable
  parameters:
    value: int((((rf_rate/2)-channel_spacing)/channel_spacing))
  states: {}
- name: rand_low
  id: variable
  parameters:
    value: int(-(((rf_rate/2)-channel_spacing)/channel_spacing))
  states: {}
- name: rf_rate
  id: variable
  parameters:
    value: rf_samp_rate
  states: {}
- name: temp_hops
  id: variable
  parameters:
    value: '[-3,-2,-1,0,1,2,3]'
  states: {}
- name: analog_nbfm_tx_0
  id: analog_nbfm_tx
  parameters:
    audio_rate: audio_rate
    fh: '-1.0'
    max_dev: 5e3
    quad_rate: if_rate
    tau: '75e-6'
  states: {}
- name: bb_gain
  id: parameter
  parameters:
    label: Base Band Gain
    short_id: b
    type: eng_float
    value: '20'
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: int(rf_rate*(1/hop_rate))
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: rf_rate
    type: complex
  states: {state: disabled}
- name: blocks_vco_c_0
  id: blocks_vco_c
  parameters:
    amplitude: '1'
    samp_rate: rf_rate
    sensitivity: 2*pi*channel_spacing
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: hopset
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: file
    repeat: 'False'
  states: {}
- name: channel_spacing
  id: parameter
  parameters:
    label: Channel Spacing
    short_id: c
    type: eng_float
    value: 100e3
  states: {}
- name: dev
  id: parameter
  parameters:
    label: Device String
    short_id: d
    type: str
    value: '''bladerf=0'''
  states: {}
- name: file
  id: parameter
  parameters:
    label: Wav File
    short_id: w
    type: str
    value: ./test.wav
  states: {}
- name: freq
  id: parameter
  parameters:
    label: Center Frequency
    short_id: f
    type: intx
    value: int(449e6)
  states: {}
- name: hop_rate
  id: parameter
  parameters:
    label: Hops per second
    type: intx
    value: '10'
  states: {}
- name: hop_set
  id: epy_module
  parameters:
    source_code: |-
      # this module will be imported in the into your flowgraph
          #generate 60 seconds worth of hop data
      import random
      import time
      import math

      def mkhopset(seed,randlow,randhigh,hps,seconds):
          # self.message_port_pub(pmt.intern('debug'), pmt.intern('Generating New Hopset'))
          # random.seed(math.ceil(time.time()))       
          random.seed(seed)       
          hops = []
          for i in range(int(math.ceil(hps*seconds))):
              hops.append(random.randint(randlow,randhigh))
          return hops
  states: {}
- name: hop_time
  id: parameter
  parameters:
    label: Seconds of Non-Repeating Hop Data
    type: eng_float
    value: '60'
  states: {}
- name: if_gain
  id: parameter
  parameters:
    label: IF Gain
    short_id: i
    type: eng_float
    value: '20'
  states: {}
- name: import_0
  id: import
  parameters:
    comment: 'IMPORTANT: After generating fhss_tx.py, manually replace the line "import fhss_tx_hop_set as hop_set" with try/except logic to support relative imports. See existing fhss_tx.py for reference.'
    imports: from math import pi
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 3e3
    decim: '1'
    gain: '1'
    samp_rate: rf_rate
    type: fir_filter_ccf
    width: 2e3
    win: window.WIN_HAMMING
  states: {}
- name: note_0
  id: note
  parameters:
    note: Hack RF uses the RF Gain to enable or disable (<14) the RF amplifier. HackRF uses IF Gain for fine gain adjustment. BladeRF Only uses RF gain, and is generally best set around 40 to 45.
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    ant0: antenna
    args: dev
    bb_gain0: bb_gain
    corr0: ppm
    freq0: freq
    gain0: rf_gain
    if_gain0: if_gain
    sample_rate: rf_rate
    sync: none
    type: fc32
  states: {}
- name: ppm
  id: parameter
  parameters:
    hide: part
    label: PPM
    short_id: p
    type: intx
    value: '0'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: if_rate
    interp: rf_rate
    type: ccc
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: wav_rate
    interp: audio_rate
    type: fff
  states: {}
- name: rf_gain
  id: parameter
  parameters:
    label: RF Gain
    short_id: g
    type: eng_float
    value: '20'
  states: {}
- name: rf_samp_rate
  id: parameter
  parameters:
    label: RF Sample Rate
    short_id: r
    type: intx
    value: '2000000'
  states: {}
- name: seed
  id: parameter
  parameters:
    label: Seed
    short_id: s
    type: str
    value: RFHS
  states: {}
- name: wav_rate
  id: parameter
  parameters:
    label: Wav File Audio Sample Rate
    short_id: a
    type: intx
    value: '48000'
  states: {}
- name: antenna
  id: parameter
  parameters:
    label: Antenna
    type: str
    value: ''
  states: {}

connections:
- [analog_nbfm_tx_0, '0', rational_resampler_xxx_0, '0']
- [blocks_multiply_xx_0, '0', blocks_throttle_0, '0']
- [blocks_multiply_xx_0, '0', osmosdr_sink_0, '0']
- [blocks_repeat_0, '0', blocks_vco_c_0, '0']
- [blocks_throttle_0, '0', blocks_null_sink_0, '0']
- [blocks_vco_c_0, '0', blocks_multiply_xx_0, '0']
- [blocks_vector_source_x_0, '0', blocks_repeat_0, '0']
- [blocks_wavfile_source_0, '0', rational_resampler_xxx_1, '0']
- [low_pass_filter_0, '0', blocks_multiply_xx_0, '1']
- [rational_resampler_xxx_0, '0', low_pass_filter_0, '0']
- [rational_resampler_xxx_1, '0', analog_nbfm_tx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
