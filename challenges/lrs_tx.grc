options:
  parameters:
    author: ChallengeCtl
    comment: |-
      LRS Pager transmitter using in-memory data.
      Note: This flowgraph receives pager data at runtime via the main() function's data parameter. The vector_source block is populated programmatically, not from a file or hardcoded values.
    description: LRS Pager TX with in-memory data source
    generate_options: no_gui
    id: lrs_tx
    output_language: python
    run_options: run
    title: LRS TX
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '2400000'
  states: {}
- name: bbgain
  id: parameter
  parameters:
    label: Base Band Gain
    short_id: b
    type: eng_float
    value: '20'
  states: {}
- name: deviceargs
  id: parameter
  parameters:
    label: Device String
    short_id: d
    type: str
    value: '''hackrf'''
  states: {}
- name: freq
  id: parameter
  parameters:
    label: Center Frequency
    short_id: f
    type: intx
    value: '467750000'
  states: {}
- name: ifgain
  id: parameter
  parameters:
    label: IF Gain
    short_id: i
    type: eng_float
    value: '20'
  states: {}
- name: rfgain
  id: parameter
  parameters:
    label: RF Gain
    short_id: g
    type: eng_float
    value: '47'
  states: {}
- name: antenna
  id: parameter
  parameters:
    label: Antenna
    short_id: a
    type: str
    value: ''
  states: {}
- name: blocks_vector_source_0
  id: blocks_vector_source_x
  parameters:
    comment: |-
      NOTE: Data is provided at runtime via main() function parameter.
      In standalone use, this would contain Manchester-encoded pager data
      (floats: 0.0001 for binary 0, 1.0 for binary 1).
    repeat: 'False'
    type: float
    vector: '[]'
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    comment: |-
      Repeat each sample 3190 times to slow down transmission
      and match pager baud rate
    interp: '3190'
    type: float
  states: {}
- name: analog_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters:
    comment: FM modulation with sensitivity 6.26 rad/sample
    sensitivity: '6.26'
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    ant0: antenna
    args: deviceargs
    bb_gain0: bbgain
    freq0: freq
    gain0: rfgain
    if_gain0: ifgain
    sample_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [blocks_vector_source_0, '0', blocks_repeat_0, '0']
- [blocks_repeat_0, '0', analog_frequency_modulator_fc_0, '0']
- [analog_frequency_modulator_fc_0, '0', osmosdr_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
